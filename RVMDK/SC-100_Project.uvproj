# Keil uVision project SC-100_Project.uvproj, settings and files
target Target (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,USE_STM3210B_EVAL
  c include: ..\Inc;..\Inc\driver;..\Inc\usb_app;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Core\CM3
  memory RVCT4: ROM 0x8004000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../src/: main.c hw_config.c stm32f10x_it.c cmd_process.c
  group Driver
    ../Src/driver/: eeprom.c mjdt-13.56.c rc632-spi.c sc.c
  group USB_APP
    ../Src/usb_app/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group STM32_USB-F
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_Std
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group RVMDK
    ../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
